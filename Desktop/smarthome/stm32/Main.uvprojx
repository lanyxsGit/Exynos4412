# Keil uVision project Main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Main
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\HARDWARE\EXTI;.\HARDWARE\L298N;.\HARDWARE\LED;.\HARDWARE\TIMER;.\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s main.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/EXTI/: exti.c
    ./HARDWARE/L298N/: l298n.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/TIMER/: timer.c
